# Keil uVision project CMSIScoreSIMD.uvproj, settings and files
target SIMD (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: SIMD
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Source Group
    ./: main.c
  group Startup
    ./: system_ARMCM4.c startup_ARMCM4.s
