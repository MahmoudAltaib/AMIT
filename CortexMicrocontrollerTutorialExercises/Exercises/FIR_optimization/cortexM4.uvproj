# Keil uVision project cortexM4.uvproj, settings and files
target DSP Optimisation (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: cortexM4
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Source Group
    ./: main.c
  group startup
    ./: system_ARMCM4.c startup_ARMCM4.s
