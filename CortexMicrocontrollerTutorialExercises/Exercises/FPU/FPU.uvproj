# Keil uVision project FPU.uvproj, settings and files
target FPU (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: FPU
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Source Group 1
    ./: system_ARMCM4.c startup_ARMCM4.s main.c
