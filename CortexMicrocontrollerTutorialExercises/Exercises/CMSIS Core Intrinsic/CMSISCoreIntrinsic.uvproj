# Keil uVision project CMSISCoreIntrinsic.uvproj, settings and files
target CMSIScoreIntrinsic (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CMSISCoreCPU
  c flags: Optim=1
  c define: STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source code
    ./: main.c system_stm32f10x.c startup_stm32f10x_md.s
