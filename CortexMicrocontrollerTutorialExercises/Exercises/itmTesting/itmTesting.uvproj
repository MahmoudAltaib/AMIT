# Keil uVision project itmTesting.uvproj, settings and files
target ITM Testing (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ./: startup_LPC17xx.s system_LPC17xx.c
  group RTX Configuration
    ./: RTX_Conf_CM.c RTX_CM3.lib
  group Source Files
    ./: main_app.c
  group Driver
    ./: LED.c Serial.c Retarget.c
  group Test Tasks
    ./: error.c test_functions.c
