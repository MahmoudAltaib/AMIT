# Keil uVision project Blinky.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD __USE_LCD __USART1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Flash Options
    ./: STM32F10xOPT.s
  group Source Files
    ./: Retarget.c LCD_4bit.c Blinky.c IRQ.c LED.c ADC.c Serial.c
  group Documentation
    ./: Abstract.txt
target STM32F103 Flash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD __USE_LCD __USART1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103 OPT (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: BlinkyOPT
  c flags: Optim=1
  c define: STM32F10X_MD __USE_LCD __USART1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103 RAM (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD VECT_TAB_SRAM __USE_LCD __USART1 __ADC_IRQ
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x2800
  memory RVCT9: RAM 0x20002800 size 0x2800
target STM32F103 Trace A (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD __USE_LCD __USART1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103 Trace B (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD __USE_LCD __USART1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target STM32F103 Trace C (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_MD __USE_LCD __USART1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
