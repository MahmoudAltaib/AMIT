# Keil uVision project DSP_App.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: DSP_App
  c flags: Optim=1
  c define: ARM_MATH_CM3 __IIR __Q31
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Configuration
    ./: RTX_Conf_CM.c
  group Source
    ./: LED.c Timer.c ADC.c DAC.c DSP_App.c DSP_IIR.c
  group DSP Library
    ./: arm_cortexM3_math.lib RTX_CM3.lib
