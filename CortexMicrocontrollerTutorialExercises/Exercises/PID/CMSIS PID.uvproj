# Keil uVision project CMSIS PID.uvproj, settings and files
target SIMD (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: SIMD
  c flags: Optim=1
  c define: ARM_MATH_CM4, __FPU_PRESENT =1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Source Group
    ./: PID_example_f32.c arm_cortexM4lf_math.lib
  group Startup
    ./: system_ARMCM4.c startup_ARMCM4.s
