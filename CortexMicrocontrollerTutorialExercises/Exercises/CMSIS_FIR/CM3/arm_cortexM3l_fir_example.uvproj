# Keil uVision project arm_cortexM3l_fir_example.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: arm_cortexM3l_fir_example
  c flags: Optim=1 wLevel=2
  c define: ARM_MATH_CM3
  c include: ..\..\Common\Include;..\..\..\..\Include;..\..\..\..\..\Device\ARM\ARMCM3\Include
  group Source Group 1
    ../: arm_fir_data.c arm_fir_example_f32.c math_helper.c
  group CMSIS Device
    ./: startup_ARMCM3.s system_ARMCM3.c
  group CMSIS DSP_Library
    ./: arm_cortexM3l_math.lib
