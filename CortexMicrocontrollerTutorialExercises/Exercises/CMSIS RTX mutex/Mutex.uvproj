# Keil uVision project Mutex.uvproj, settings and files
target Mutex (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mutex
  c flags: Optim=1
  c define: STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s system_stm32f10x.c RTX_CM3.lib RTX_Conf_CM.c led.c main.c uart.c
